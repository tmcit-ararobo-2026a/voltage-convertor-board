# Repository tmcit-ararobo-2026a/voltage-convertor-board

## KiCad design voltage-convertor-board/voltage-convertor-board.kicad_pcb

Parts:
C1, C2, C3, C4, C15, C16, C17: 0.1u; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C5: 1uf; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C6, C11: 0.1uf; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C7: 4700pf; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C8: 47pF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C9, C10: 4.7uf; C_1210_3225Metric_Pad1.33x2.70mm_HandSolder
C12, C13: 47uf; C_1210_3225Metric_Pad1.33x2.70mm_HandSolder
C14: 220uf; C_Radial_D8.0mm_H7.0mm_P3.50mm
C18: 0.47u; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C19: 470uf; CP_Radial_D10.0mm_P5.00mm
D1: RB088LAM-60; D_SOD-128
D2, D3, D4, D5, D6, D7, D8, D9, D10, D11: LED; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
F1: Fuse; Fuse_1812_4532Metric_Pad1.30x3.40mm_HandSolder
IC1: MCP2562; SOIC127P600X175-8N; Mouser Part Number 771-TJA1441AT/0Z
J1, J4, J5, J7: Conn_01x04; JST_XH_S4B-XH-A_1x04_P2.50mm_Horizontal
J2, J3, J8, J9: Conn_01x03; JST_XH_S3B-XH-A_1x03_P2.50mm_Horizontal
J6: Conn_01x04_Pin; PinHeader_1x04_P2.54mm_Vertical
J10: Conn_01x02; AMASS_XT60PW-M_1x02_P7.20mm_Horizontal
J11: Conn_01x02; AMASS_XT60PW-F_1x02_P7.20mm_Horizontal
JP1: Jumper_2_Open; TestPoint_2Pads_Pitch2.54mm_Drill0.8mm
L1: 10uH; XAL6060103MEC
Q1, Q2, Q3, Q4: BSS138; SOT-23
R1: 243k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R2: 16.9k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R3: 90.9k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R4: 442k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R5: 140k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R6, R7, R8, R9, R10, R11, R13, R14, R15, R16: 10k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R12: 120; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R17, R18, R19, R20, R21, R22, R23, R24, R25, R26: 1k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
SW1: SW_Push; switch_TVAF06-A020B-R
U1: TPS54560BDDA; Texas_R-PDSO-G8_EP2.95x4.9mm_Mask2.4x3.1mm_ThermalVias
U2: NJM12888F33; SOT-23-5_HandSoldering
U5: STM32G431K8Tx; LQFP-32_7x7mm_P0.8mm
U6: NJM7805SDL1; TO-252-2

Connections:
+3.3V: C1.1, C2.1, C4.1, C16.1, C18.1, IC1.5 (VIO), J6.4, J7.2, R9.1, R11.1, R14.1, R16.1, R25.1, U2.5 (VOUT), U5.1 (VDD), U5.15 (VDDA), U5.17 (VDD)
+5V: C15.1, C17.1, IC1.3 (VCC), J4.3, J5.3, R24.1, U2.1 (VIN), U2.3 (CONTROL)
+5VP: C6.1, J1.3, R22.1, U6.3 (VOUT)
+12V: C12.1, C13.1, C14.1, F1.1, J11.2, L1.2, R5.1, R21.1
+12VA: F1.2, J2.3, J3.3, J8.3, J9.3, R26.1
CANH: IC1.7 (CANH), J4.4, J5.4, JP1.1 (A)
CANL: IC1.6 (CANL), J4.2, J5.2, R12.2
CAN_RX: IC1.4 (RXD), U5.21 (PA11)
CAN_TX: IC1.1 (TXD), U5.22 (PA12)
GNDD: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C12.2, C13.2, C14.2, C15.2, C16.2, C17.2, C18.2, C19.2, D1.2 (A), D2.1 (K), D3.1 (K), D4.1 (K), D5.1 (K), D6.1 (K), D7.1 (K), D8.1 (K), D9.1 (K), D10.1 (K), D11.1 (K), IC1.2 (GND), IC1.8 (S), J1.1, J2.1, J3.1, J4.1, J5.1, J6.2, J7.4, J8.1, J9.1, J10.1, J11.1, Q1.2 (S), Q2.2 (S), Q3.2 (S), Q4.2 (S), R1.2, R3.2, R6.2, R7.1, R8.2, R10.2, R13.2, R15.2, SW1.1, U1.7 (GND), U1.9 (GND), U2.2 (GND), U5.14 (VSSA), U5.16 (VSS), U5.32 (VSS), U6.2 (GND)
IN1: Q3.3 (D), R14.2, U5.10 (PA5)
IN2: Q4.3 (D), R16.2, U5.11 (PA6)
IN3: Q1.3 (D), R9.2, U5.12 (PA7)
IN4: Q2.3 (D), R11.2, U5.9 (PA4)
LED1: R17.1, U5.5 (PA0)
LED2: R18.1, U5.6 (PA1)
LED3: R19.1, U5.7 (PA2)
LED4: R23.1, U5.8 (PA3)
NRST: C3.1, SW1.2, U5.4 (PG10)
unnamed: C7.1, R2.2
unnamed: C11.2, D1.1 (K), L1.1, U1.8 (SW)
unnamed: D2.2 (A), R17.2
unnamed: D3.2 (A), R18.2
unnamed: D4.2 (A), R19.2
unnamed: D5.2 (A), R20.2
unnamed: D6.2 (A), R21.2
unnamed: D7.2 (A), R22.2
unnamed: D8.2 (A), R23.2
unnamed: D9.2 (A), R24.2
unnamed: D10.2 (A), R25.2
unnamed: D11.2 (A), R26.2
unnamed: J2.2, Q1.1 (G), R8.1
unnamed: J3.2, Q2.1 (G), R10.1
unnamed: J8.2, Q3.1 (G), R13.1
unnamed: J9.2, Q4.1 (G), R15.1
unnamed: JP1.2 (B), R12.1
unnamed: C11.1, U1.1 (BOOT)
unnamed: C8.1, R2.1, U1.6 (COMP)
unnamed: R3.1, R4.2, U1.3 (EN)
unnamed: R5.2, R6.1, U1.5 (FB)
unnamed: R1.1, U1.4 (RT/CLK)
unnamed: R7.2, U5.31 (PB8)
SWCLK: J6.3, U5.24 (PA14)
SWDIO: J6.1, U5.23 (PA13)
UART_RX: J7.1, U5.30 (PB7)
UART_TX: J7.3, U5.29 (PB6)
VCC: C5.1, C9.1, C10.1, C19.1, J10.2, R4.1, R20.1, U1.2 (VIN), U6.1 (VIN)

Notes on the sheet:
5V 出力
STM32
電源入力
CANトランシーバー
UART
STLink
LED
リセットSW
12V出力
CAN

Board: 2 copper layers, 60.0 x 70.0 mm, 80 parts (3 on the bottom side), 47 nets.

File voltage-convertor-board/production/bom.csv:

Designator,Footprint,Quantity,Value,LCSC Part #
"C1, C15, C16, C17, C2, C3, C4",0603,7,0.1u,
"C10, C9",1210,2,4.7uf,
"C11, C6",0603,2,0.1uf,
"C12, C13",1210,2,47uf,
C14,C_Radial_D8.0mm_H7.0mm_P3.50mm,1,220uf,
C18,0603,1,0.47u,
C19,CP_Radial_D10.0mm_P5.00mm,1,470uf,
C5,0603,1,1uf,
C7,0603,1,4700pf,
C8,0603,1,47pF,
D1,D_SOD-128,1,RB088LAM-60,
"D10, D11, D2, D3, D4, D5, D6, D7, D8, D9",0603,10,LED,
F1,1812,1,Fuse,
IC1,SOIC127P600X175-8N,1,MCP2562,
"J1, J4, J5, J7",JST_XH_S4B-XH-A_1x04_P2.50mm_Horizontal,4,Conn_01x04,
J10,AMASS_XT60PW-M_1x02_P7.20mm_Horizontal,1,Conn_01x02,
J11,AMASS_XT60PW-F_1x02_P7.20mm_Horizontal,1,Conn_01x02,
"J2, J3, J8, J9",JST_XH_S3B-XH-A_1x03_P2.50mm_Horizontal,4,Conn_01x03,
J6,PinHeader_1x04_P2.54mm_Vertical,1,Conn_01x04_Pin,
JP1,TestPoint_2Pads_Pitch2.54mm_Drill0.8mm,1,Jumper_2_Open,
L1,XAL6060103MEC,1,10uH,
"Q1, Q2, Q3, Q4",SOT-23,4,BSS138,
R1,0603,1,243k,
"R10, R11, R13, R14, R15, R16, R6, R7, R8, R9",0603,10,10k,
R12,0603,1,120,
"R17, R18, R19, R20, R21, R22, R23, R24, R25, R26",0603,10,1k,
R2,0603,1,16.9k,
R3,0603,1,90.9k,
R4,0603,1,442k,
R5,0603,1,140k,
SW1,switch_TVAF06-A020B-R,1,SW_Push,
U1,Texas_R-PDSO-G8_EP2.95x4.9mm_Mask2.4x3.1mm_ThermalVias,1,TPS54560BDDA,
U2,SOT-23-5_HandSoldering,1,NJM12888F33,
U5,LQFP-32_7x7mm_P0.8mm,1,STM32G431K8Tx,
U6,TO-252-2,1,NJM7805SDL1,

## Commit log

2026-05-03 回路図完成
2026-05-04 PCB シルク、ビア、LED以外完成
2026-05-04 ビア以外完成
